File: pcb/pcb.kicad_pcb (KiCad board)
At the start: 2 copper layers, 132.5 x 101.5 mm, 46 parts

Commit message: feat(gerbers): upload gerbers
Other:
- rule pad_to_mask_clearance: 0.05 -> 0
